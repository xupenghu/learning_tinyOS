# Keil uVision project tinyOS.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: tinyOS +hex
  c flags: Optim=1 wLevel=2
  c include: .\sourse
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./sourse/: main.c bitmap.c list.c t_cpu.c t_task.c t_time.c app.c t_event.c t_sem.c t_mbox.c t_mem_block.c t_flag_group.c t_mutex.c t_timer.c
    ./: switch.c
  group DOC
    ./: README
  group ::Device
    RTE/Device/ARMCM3/: startup_ARMCM3.s system_ARMCM3.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
